# Keil uVision project 06c-UART_Tx_String.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 06c-UART_Tx_String
  AfterMake: fromelf --bin 06c-UART_Tx_String.axf --output 06c-UART_Tx_String.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s main.c
    ../00-libfiles/: delay.c gpio.c system_LPC17xx.c uart.c adc.c timer.c serial.c rit.c
  group Header files
    ../00-libfiles/: gpio.h uart.h delay.h adc.h timer.h stdutils.h serial.h rit.h ritDefine.h uart023Define.h
software components: CMSIS:CORE 5.2.0
