# Keil uVision project esp8266.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: esp8266
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\00-libfiles
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
    ./00-libfiles/: uart.c gpio.c delay.c
  group Header
    ./00-libfiles/: delay.h gpio.h uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
