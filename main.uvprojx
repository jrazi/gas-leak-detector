# Keil uVision project main.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c gateway.c gateway.h parser.c parser.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Test:Unity 2.5.0, Compiler:Event Recorder 1.4.0, Network:CORE 7.14.0, Network:Interface:WiFi 7.14.0, Network:Socket:TCP 7.14.0, Network:Socket:UDP 7.14.0, CMSIS Driver:USART 2.10.0, CMSIS Driver:WiFi:ESP8266 1.4.0, Data Exchange:JSON:Jansson 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0, IoT Utility:http-parser 2.9.2
